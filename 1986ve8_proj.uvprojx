# Keil uVision project 1986ve8_proj.uvprojx, settings and files
target Target (IntRAM) (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: 1986ve8_proj +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: _INT_RAM_
  memory RVCT4: ROM 0x20000000 size 0x6000
  memory RVCT9: RAM 0x20006000 size 0x2000
  group Source Group 1
    ./Sources/: sysinit.c main.c eerom.c mko.c wdt.c uarts.c adc.c timers.c gpio.c mbkap.c power_management.c crc16.c stm.c mpp.c dir.c
  group 1986ve8_lib
    ./Sources/1986ve8_lib/: core_cm4.c startup_MDR1986VE8T.s
target Target (ExtMEM Dbg) (ARM-ADS)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: 1986ve8_proj +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target Target (ExtMEM Rls) (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: 1986ve8_proj +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: _EXT_MEM_RLS_
  memory RVCT1: ROM 0x10000000 size 0x8000
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
